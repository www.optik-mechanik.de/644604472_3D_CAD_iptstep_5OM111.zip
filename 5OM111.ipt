# Autodesk Inventor part: 5OM111_uzsakovui
## iProperties
Created: 2006-11
Part Number: 5OM111_uzsakovui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
